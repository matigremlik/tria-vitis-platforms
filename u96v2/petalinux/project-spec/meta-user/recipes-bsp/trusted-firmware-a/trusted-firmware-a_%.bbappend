# Keep ATF artifact names stable across builds to avoid DATETIME-based mismatches.
ATF_BASE_NAME:forcevariable = "arm-trusted-firmware-${PV}-${PR}"
